!Keysight Technologies,N5245B,MY57181321,A.14.80.03
!Date: Thursday, March 28, 2024 17:37:23
!Correction: S11(C  2-Port  )
!S21(C  2-Port  )
!S12(C  2-Port  )
!S22(C  2-Port  )
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  RI  R 50
! Worked out from all points (one-way two-port):
!   4000 points, 10 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -25.42 dB at 38.24 GHz (marker M1); lowest = -84.8 dB at 5.01 GHz (marker M2)
!   lowest |S11| = -42.5 dB at 17.14 GHz (marker M3), VSWR 1.02, Z = 50.7 - j0.124 ohm
!   |S11| at or under -10 dB: 16.72 GHz to 17.77 GHz (1.047 GHz wide, 6.07 % of centre); 21.76 GHz to 22.66 GHz (898.5 MHz wide, 4.05 % of centre); 23.22 GHz to 24.3 GHz (1.076 GHz wide, 4.53 % of centre) (the widest 3 of 14)
!   |S22| runs from -32.7 to 0.0 dB; largest |S21 - S12| = 0.074
!   the Smith chart shows 12.87 GHz to 20.98 GHz only
!   S11 on the Smith chart (normalised r, x): 12.87 GHz: 0.18, -0.74; 14.53 GHz: 0.43, -0.03; 16.32 GHz: 1.71, +0.70; 17.99 GHz: 2.06, +0.27; 19.59 GHz: 1.53, -0.38; 20.98 GHz: 1.45, +0.08
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.1  -31.9  -29.2  0.0
! 970 MHz  -1.2  -49.5  -51.4  -0.7
! 5.01 GHz  -5.1  -84.8  -47.7  -1.2
! 6.68 GHz  -3.9  -54.5  -53.1  -1.1
! 12.87 GHz  -2.1  -58.2  -51.2  -8.6
! 13.34 GHz  -4.9  -49.3  -50.2  -4.6
! 14.53 GHz  -7.9  -51.8  -40.3  -9.9
! 16.32 GHz  -9.0  -53.8  -55.6  -12.5
! 17.14 GHz  -42.5  -50.9  -43.8  -14.9
! 17.99 GHz  -9.0  -52.3  -41.4  -15.1
! 18.64 GHz  -27.9  -44.3  -47.1  -9.6
! 19.21 GHz  -9.1  -46.6  -45.4  -23.5
! 19.59 GHz  -11.9  -46.7  -50.1  -11.3
! 20.01 GHz  -19.2  -44.1  -46.7  -8.3
! 20.98 GHz  -14.6  -48.0  -43.9  -14.7
! 23.08 GHz  -9.4  -48.2  -48.7  -12.6
! 23.88 GHz  -35.3  -50.4  -46.2  -25.0
! 24.87 GHz  -7.5  -43.7  -50.7  -29.1
! 26.67 GHz  -13.5  -41.0  -37.4  -7.6
! 33.34 GHz  -2.4  -42.1  -50.7  -1.8
! 38.24 GHz  4.4  -25.4  -31.0  -5.4
! 40 GHz  4.9  -36.1  -37.1  -11.1
