!Keysight Technologies,N5245B,MY57181321,A.14.80.03
!Date: Thursday, March 28, 2024 19:40:30
!Correction: S11(C  2-Port  )
!S21(C  2-Port  )
!S12(C  2-Port  )
!S22(C  2-Port  )
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  RI  R 50
! Worked out from all points (one-way two-port):
!   4000 points, 10 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -26.33 dB at 37.68 GHz (marker M1); lowest = -92.4 dB at 640 MHz (marker M2)
!   lowest |S11| = -54.7 dB at 16.01 GHz (marker M3), VSWR 1.00, Z = 50.2 - j0.0788 ohm
!   |S11| at or under -10 dB: 15.56 GHz to 21.43 GHz (5.868 GHz wide, 31.7 % of centre); 21.72 GHz to 24.66 GHz (2.939 GHz wide, 12.7 % of centre); 25.62 GHz to 26.27 GHz (651.6 MHz wide, 2.51 % of centre) (the widest 3 of 7)
!   |S22| runs from -36.1 to -0.3 dB; largest |S21 - S12| = 0.073
!   the Smith chart shows 11.36 GHz to 21.3 GHz only
!   S11 on the Smith chart (normalised r, x): 11.36 GHz: 0.89, -2.35; 13.45 GHz: 0.45, -0.66; 15.32 GHz: 0.50, +0.20; 17.39 GHz: 1.09, -0.21; 19.48 GHz: 1.42, -0.27; 21.3 GHz: 0.85, +0.47
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  0.0  -30.9  -48.2  -1.0
! 640 MHz  -1.1  -92.4  -54.9  -0.5
! 6.68 GHz  -4.6  -50.4  -49.7  -1.1
! 11.36 GHz  -2.2  -56.7  -47.2  -5.6
! 13.34 GHz  -4.8  -44.6  -43.7  -6.3
! 13.45 GHz  -5.4  -49.0  -46.5  -5.6
! 15.32 GHz  -9.0  -48.8  -50.2  -7.0
! 16.01 GHz  -54.7  -46.1  -48.9  -17.1
! 16.49 GHz  -11.8  -49.2  -55.9  -13.7
! 17.39 GHz  -19.2  -48.0  -54.1  -15.0
! 18.71 GHz  -28.2  -41.3  -48.3  -9.6
! 19.48 GHz  -13.8  -50.0  -46.5  -17.0
! 20.01 GHz  -18.9  -48.6  -41.6  -9.6
! 21.3 GHz  -11.8  -48.3  -48.5  -20.0
! 21.83 GHz  -10.9  -49.8  -49.1  -13.2
! 22.4 GHz  -24.7  -48.8  -44.3  -34.0
! 23.18 GHz  -11.4  -43.7  -52.7  -11.6
! 24.01 GHz  -15.9  -43.2  -48.1  -29.7
! 26.67 GHz  -7.9  -34.8  -37.6  -9.5
! 33.34 GHz  -1.3  -42.9  -53.8  -2.3
! 37.68 GHz  -2.2  -26.3  -38.3  -7.0
! 40 GHz  1.3  -44.6  -42.0  -10.1
