!Keysight Technologies,N5245B,MY57181321,A.14.80.03
!Date: Thursday, March 28, 2024 18:48:03
!Correction: S11(C  2-Port  )
!S21(C  2-Port  )
!S12(C  2-Port  )
!S22(C  2-Port  )
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  RI  R 50
! Worked out from all points (one-way two-port):
!   4000 points, 10 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -24.95 dB at 38.49 GHz (marker M1); lowest = -89.2 dB at 15.18 GHz (marker M2)
!   lowest |S11| = -35.4 dB at 26.67 GHz (marker M3), VSWR 1.03, Z = 51.7 - j0.177 ohm
!   |S11| at or under -10 dB: 16.9 GHz to 17.63 GHz (728.5 MHz wide, 4.22 % of centre); 20.62 GHz to 21.35 GHz (725.8 MHz wide, 3.46 % of centre); 23.19 GHz to 24.22 GHz (1.031 GHz wide, 4.35 % of centre) (the widest 3 of 12)
!   |S22| runs from -35.0 to 1.0 dB; largest |S21 - S12| = 0.077
!   the Smith chart shows 23.48 GHz to 30.17 GHz only
!   S11 on the Smith chart (normalised r, x): 23.48 GHz: 0.71, +0.30; 25.21 GHz: 1.43, +0.08; 26.79 GHz: 0.90, -0.20; 27.73 GHz: 2.44, -0.62; 30.17 GHz: 1.64, -0.84
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  0.1  -38.3  -28.7  0.0
! 1.27 GHz  -1.2  -50.1  -51.0  -0.4
! 6.68 GHz  -3.2  -54.7  -46.8  -0.6
! 13.34 GHz  -3.6  -48.5  -44.0  -3.3
! 15.18 GHz  -3.7  -89.2  -49.6  -3.8
! 17.21 GHz  -18.9  -48.4  -43.9  -14.3
! 18.03 GHz  -6.9  -55.7  -45.4  -12.9
! 18.64 GHz  -19.0  -46.8  -44.7  -7.9
! 19.23 GHz  -6.4  -45.6  -41.0  -30.8
! 20.01 GHz  -18.8  -45.3  -55.0  -6.2
! 21.97 GHz  -19.7  -51.2  -49.3  -35.0
! 22.79 GHz  -7.8  -59.2  -58.4  -6.6
! 23.48 GHz  -12.3  -45.5  -47.2  -22.6
! 25.21 GHz  -14.9  -43.2  -49.7  -12.9
! 26.08 GHz  -6.7  -49.3  -43.2  -11.3
! 26.67 GHz  -35.4  -37.4  -38.3  -3.8
! 26.79 GHz  -18.6  -34.8  -40.6  -3.4
! 27.73 GHz  -7.0  -39.3  -39.2  -5.2
! 30.17 GHz  -8.4  -54.0  -45.7  -2.5
! 33.34 GHz  -2.7  -48.3  -41.3  -2.9
! 38.49 GHz  7.2  -24.9  -30.5  -3.4
! 40 GHz  1.3  -42.1  -30.2  -1.9
